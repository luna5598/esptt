# Keil uVision project limb.uvproj, settings and files
target STC32G12K128 R01 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(24000000)
  output: limb +hex
  link misc: REMOVEUNUSED
  group R01
    ./: main.c board.c
  group Shared node
    ../: node_target.c temperature_node.c tip_acquisition.c
